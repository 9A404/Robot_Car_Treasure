# Keil uVision project Car.uvprojx, settings and files
target Template (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\PWM;..\HARDWARE\PID;..\HARDWARE\MYIIC;..\ALGORITHM\DMP;..\ALGORITHM\CONTROL;..\ALGORITHM\METHOD;..\HARDWARE\USART3;..\ALGORITHM\CONTROL;..\ALGORITHM\METHOD;..\ALGORITHM\DMP;..\HARDWARE\MPU6050;..\HARDWARE\KEY;..\HARDWARE\PHOTOELECTRIC;..\HARDWARE\LED;..\HARDWARE\LCD;..\ALGORITHM\MYGUI;..\HARDWARE\BELL;..\ALGORITHM\DANGER;..\ALGORITHM\TREASURE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_usart.c misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAEDWARE
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: Timer.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/MYIIC/: myiic.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/PHOTOELECTRIC/: pes.c
    ../HARDWARE/LED/: led.c
    ../ALGORITHM/CONTROL/: control.c
    ../HARDWARE/LCD/: Lcd_Driver.c GUI.c
    ../HARDWARE/BELL/: bell.c
  group ALGORITHM
    ../ALGORITHM/MYGUI/: myGUI.c
    ../ALGORITHM/METHOD/: findline.c roadblock.c seeknodeway.c carpark.c rotangle.c speed.c
    ../ALGORITHM/MAP/: map.c
    ../ALGORITHM/DANGER/: danger.c
    ../ALGORITHM/TREASURE/: Treasure.c
  group MPU6050_LIB
    ../ALGORITHM/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group README
    ../README/: readme.txt test_code.c
software components: CMSIS:CORE 3.40.0
